# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\Bsp; ..\Bsp\StdPeriph_Lib\CMSIS\CoreSupport; ..\Bsp\StdPeriph_Lib\CMSIS\DeviceSupport; ..\Bsp\StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc; ..\User; ..\uCOS-II\Ports; ..\uCOS-II\Source; ..\uCOS-II\uC-CPU; ..\uCOS-II\uC-LIB
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Bsp
    ../Bsp/: beep.c bsp.c led.c
  group Bsp/StdPeriph_Lib/CMSIS
    ../Bsp/StdPeriph_Lib/CMSIS/CoreSupport/: core_cm3.c
    ../Bsp/StdPeriph_Lib/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Bsp/StdPeriph_Lib/CMSIS/Startup
    ../Bsp/StdPeriph_Lib/CMSIS/DeviceSupport/startup/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group Bsp/StdPeriph_Lib/StdPeriph_Driver
    ../Bsp/StdPeriph_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS-II/Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c
  group uCOS-II/Source
    ../uCOS-II/Source/: ucos_ii.c
  group uCOS-II/uC-CPU
    ../uCOS-II/uC-CPU/: cpu_a.asm cpu_c.c
  group uCOS-II/uC-LIB
    ../uCOS-II/uC-LIB/: lib_ascii.c lib_mem.c lib_str.c
  group User
    ../User/: app_hook.c common.c DL645.c key.c lcd.c link_manager.c main.c plc.c queue.c stm32f10x_it.c uart_link.c
